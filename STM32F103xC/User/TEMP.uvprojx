# Keil uVision project TEMP.uvprojx, settings and files
target TEMP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEMP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Src\HARDWARE\KEY;..\Src\HARDWARE\LED;..\Src\HARDWARE\LCD;..\Src\HARDWARE\STMFLASH;..\Src\SYSTEM\delay;..\Src\SYSTEM\sys;..\Src\SYSTEM\usart;..\Src\STM32F10x_FWLib\inc;..\Src\STM32F10x_FWLib\core;..\Src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../Src/: main.c stm32f10x_it.c
  group Hardware
    ../Src/HARDWARE/KEY/: key.c
    ../Src/HARDWARE/LED/: led.c
    ../Src/HARDWARE/STMFLASH/: stmflash.c
    ../Src/HARDWARE/LCD/: lcd.c
  group System
    ../Src/SYSTEM/usart/: usart.c
    ../Src/SYSTEM/sys/: sys.c
    ../Src/SYSTEM/delay/: delay.c
  group Core
    ../Src/STM32F10x_FWLib/core/: core_cm3.c system_stm32f10x.c
    ../Src/STM32F10x_FWLib/startup/: startup_stm32f10x_hd.s
  group FWLlib
    ../Src/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
